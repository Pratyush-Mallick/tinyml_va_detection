# Keil uVision project ei_ecg_float_min_dsp_test.uvprojx, settings and files
target ei_ecg_float_min_dsp_test (6180000::V6.18::ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ei_ecg_float_min_dsp_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L432xx,ARM_TABLE_TWIDDLECOEF_F32_64, ARM_TABLE_BITREVIDX_FLT_64, ARM_TABLE_TWIDDLECOEF_RFFT_F32_128
  c include: ../Inc;../Middlewares/ST/AI/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: ei_ecg_float_min_dsp_test.sct
  group Application/MDK-ARM
    ./: startup_stm32l432xx.s
  group Application/User
    ../Src/: network.c network_data.c network_data_params.c main.c gpio.c crc.c app_x-cube-ai.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c ei_pre_process.c
  group Doc
    ..//: network_generate_report.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c stm32l4xx_ll_exti.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_tim.c stm32l4xx_ll_gpio.c stm32l4xx_ll_dma.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime720_CM4_Keil.lib
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
